<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/azure_cc32xx_tirtos_builds_CC3220S_LAUNCHXL_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
